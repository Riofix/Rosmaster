# Keil uVision project Slave.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Slave +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\FWlib\inc;.\FWlib\src;.\Src\APP;.\Src\BSP;.\Src\Protocol;..\Common
  memory RVCT4: ROM 0x8000000 size 0x1c00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Support
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group APP
    ./Src/APP/: main.c stm32f10x_it.c stm32f10x_conf.h flash_if.c flash_if.h slot_manager.c
  group BSP
    ./Src/BSP/: bsp_systick.c bsp_systick.h bsp_usart.c bsp_usart.h OLED.c OLED.h OLED_Font.h

# Keil uVision project Slave.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Slave +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\FWlib\inc;.\FWlib\src;.\Src\APP;.\Src\BSP;.\Src\Protocol
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Support
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group APP
    ./Src/APP/: main.c stm32f10x_it.c stm32f10x_conf.h app.c app.h app_imu.c app_imu.h app_motor.h app_motor.c app_rgb.h app_rgb.c app_bldc.c app_bldc.h app_servo.c app_servo.h app_action.c app_action.h
  group BSP
    ./Src/BSP/: bsp_esp8266.h bsp_esp8266.c bsp_iic.c bsp_iic.h bsp_systick.c bsp_systick.h bsp_usart.c bsp_usart.h Emm_V5.c Emm_V5.h OLED.c OLED.h OLED_Font.h bsp_pwm.c bsp_pwm.h bsp_mpu6050.c bsp_mpu6050.h bsp_tcs3472.c bsp_tcs3472.h bsp_timer.c bsp_timer.h
  group Protocol
    ./Src/Protocol/: msg_queue.c msg_queue.h protocol.c protocol.h protocol_emm.c protocol_emm.h cmd_handle.c cmd_handle.h
